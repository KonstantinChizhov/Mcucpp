# IAR project GPIO.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: 5.srec
  ILINK.IlinkOutputFile: cpp.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F100xB ST STM32F100xB
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pe111
  ICCARM.CCIncludePath2: ../../mcucpp; ../../mcucpp/ARM/STM32
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.cpp
