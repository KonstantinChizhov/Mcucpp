# IAR project GPIO.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-sf-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.newCCIncludePaths: ../../mcucpp; ../../mcucpp/AVR
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm16.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3t-ec_mul-sf-n.h
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCDiagSuppress: Pe111
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(DATA)=$EXE_DIR$\$PROJ_FNAME$_data.hex; -Ointel-extended,(XDATA)=$EXE_DIR$\$PROJ_FNAME$_eeprom.hex
  group (top)
    ./: main.cpp
